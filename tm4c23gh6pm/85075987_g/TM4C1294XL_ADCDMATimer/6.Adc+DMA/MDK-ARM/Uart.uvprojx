# Keil uVision project Uart.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PART_TM4C1294NCPDT
  c include: ..\DriverLib\inc;..\DriverLib\driverlib;..\DriverLib;..\User\Bsp\inc;..\User\Fifo
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group main
    ./: main.c
  group DriverLib
    ../DriverLib/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Bsp
    ../User/Bsp/inc/: bsp.h
    ../User/Bsp/src/: bsp_dwt.c bsp_led.c bsp_adc.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
