# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C123GH6PM, TARGET_IS_BLIZZARD_RB1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ..\..\tm4c;..\USER;..\CORE;..\LIB;..\LIB\driverlib;..\LIB\inc;..\LIB\utils;..\LIB\screen;..\LIB\iIC;..\DSP_LIB;..\DSP_LIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../USER/: main.c start.c LED.c key.c time0.c lxy_ADC.c lxy_PWM.c lxy_uart.c fft.c
  group LIB
    ../LIB/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c uartstdio.c
    ../LIB/screen/: uc1701.c
    ../LIB/iIC/: pcf8575.c
  group CORE
    ../CORE/: startup_rvmdk.S
  group DSP
    ../DSP_LIB/: arm_cortexM4lf_math.lib
